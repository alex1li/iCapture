# Keil uVision project iCanSeeYourAnswers.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: Keil.Kinetis_SDK_DFP.2.2.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: testUart
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  group Source Group 1
    ./: utils.c utils.h iCapture.c matrixControl.h matrixControl.c
software components: CMSIS:CORE 5.0.2, Board Support:Accelerometer 1.2, Board Support:Buttons 1.2, CMSIS Driver:I2C 1.3, CMSIS Driver:USART 1.2, Device:KSDK Configuration:FRDM-K64F 1.2.0, Device:KSDK Driver:GPIO 1.2.0, Device:KSDK Driver:RTC 1.2.0, Device:KSDK Driver:UART 1.2.0, Device:KSDK Driver:eDMA 1.2.0, Device:KSDK HAL:DMAMUX 1.2.0, Device:KSDK HAL:GPIO 1.2.0, Device:KSDK HAL:I2C 1.2.0, Device:KSDK HAL:LPTMR 1.2.0, Device:KSDK HAL:MCG 1.2.0, Device:KSDK HAL:OSC 1.2.0, Device:KSDK HAL:PORT 1.2.0, Device:KSDK HAL:RTC 1.2.0, Device:KSDK HAL:SIM 1.2.0, Device:KSDK HAL:UART 1.2.0, Device:KSDK HAL:eDMA 1.2.0, Device:KSDK OSA:OSA 1.2.0, Device:KSDK System:Clock 1.2.0, Device:KSDK System:Interrupt 1.2.0, Device:KSDK Utility:Debug Console 1.2.0, Device:Startup 2.8
